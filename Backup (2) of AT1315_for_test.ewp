# IAR project Backup (2) of AT1315_for_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2214 Philips LPC2214
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\ARM_proj\IAR_BDKG_noPLL\LPC2xxx_ROM.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AnswerCOM.cpp BDKGmain.cpp evba7_cstartup.s79 I2C_EEPROM.c InterEINT0.cpp InterTMR0.cpp InterTMR1.cpp InterUART0.cpp
