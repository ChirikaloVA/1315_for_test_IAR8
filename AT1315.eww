<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BDKGnoPLL.ewp</path>
    <scc>
      <provider>Microsoft Visual SourceSafe</provider>
      <projname>"$/AT1315/AT1315(ARM_proj)", GKLCAAAA</projname>
      <auxprojpath>\\Newserv3\VSS\,</auxprojpath>
    </scc>
  </project>
  <batchBuild/>
</workspace>


