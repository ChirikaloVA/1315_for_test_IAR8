# IAR project BDKGmain.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
